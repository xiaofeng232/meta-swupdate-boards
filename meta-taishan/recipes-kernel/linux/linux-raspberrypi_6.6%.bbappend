FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# SRC_URI += " \
#     file://patch-6.6.63-rt47-rc2.patch.xz \
# "

# KERNEL_DEFCONFIG = "defconfig-rt-6.6"