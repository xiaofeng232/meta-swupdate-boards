# do_deploy:append:taishan-64() {
#     # Your code
#     echo "This is a taishan-64 specific deployment step."
#     echo "device_tree=bcm2711-rpi-4-b-taishan.dtb" >> $CONFIG
# }